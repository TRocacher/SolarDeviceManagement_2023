# Keil uVision project TP2_COM.uvprojx, settings and files
target Simu (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TP1_c
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LCD_SIMULATOR
  c include: .\Pilotes\include;.\Service;.\Service\Services_Xbee_et_GSM
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ./: Principal.c
  group Services
    ./Service/: API_ADC.c LCD_4bit.c FctDiverses_v2.c API_Xbee_ModeAT_2022.c
  group Pilotes
    ./Pilotes/: clock.c Drivers_STM32F103_107_Juin2018a.lib USART_rev2021.c
target Reel (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: Dev_IS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Pilotes\include;.\Service;.\Service\Services_Xbee_et_GSM
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
