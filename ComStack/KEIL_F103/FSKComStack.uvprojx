# Keil uVision project FSKComStack.uvprojx, settings and files
target Simu103 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FSKComStack
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Src;..\Stack_Src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./Src/: UART_FSK_103.c Application.c
  group Stack
    ../Stack_Src/: ExchangeLayer.c PhyUART.c TimeOut.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
