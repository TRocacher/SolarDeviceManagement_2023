# Keil uVision project FSKComStack.uvprojx, settings and files
target Simu103 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FSKComStack
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Service_RTC_DS1307;..\..\..\ComStack\FSK_Stack\Stack_Src;..\..\..\ComStack\FSK_Stack\KEIL_F103\Stack_Src_103
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./Src/: MACPhyUART_Test3.c
  group Stack
    ../../../ComStack/FSK_Stack/Stack_Src/: ModuleFSK.c ProtocoleFcts.c TimeManagement.c FSKStack.c
  group OtherServices
    ./Src/: StringFct.c MyLCD.c
    ../Service_RTC_DS1307/: Driver_DS1307.c
  group Drivers
    ../Service_RTC_DS1307/: MyI2C.c
    ../../../ComStack/FSK_Stack/KEIL_F103/Stack_Src_103/: GPIO_F103.c Timer_F103.c UART_F103.c
target STlink (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: FSKComStack
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
